# Keil uVision project N32H48x_CherryUSB.uvprojx, settings and files
target n32h48x_host (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H487ZE Nationstech
  pack: Nationstech.N32H48x_DFP.0.9.0
  cpu: IRAM(0x20000000,0x30000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: USBHS_CDC +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: N32H487, USE_STDPERIPH_DRIVER,USBHS_HOST
  c include: ..\USBD;..\USER;..\BSP;..\..\firmware\CMSIS\core;..\..\firmware\CMSIS\device;..\..\firmware\n32h47x_48x_std_periph_driver\inc;..\..\middlewares\CherryUSB\core;..\..\middlewares\CherryUSB\common;..\..\middlewares\CherryUSB\class\cdc;..\..\middlewares\CherryUSB\class\hid;..\..\middlewares\CherryUSB\class\msc;..\..\middlewares\CherryUSB\class\hub;..\..\middlewares\FreeRTOS\FreeRTOS-Kernel\include;..\..\middlewares\FreeRTOS\FreeRTOS-Kernel\portable\RVDS\ARM_CM4F;..\..\middlewares\FATFS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group STARTUP
    ../../firmware/CMSIS/device/startup/: startup_n32h487.s
  group CMSIS
    ../../firmware/CMSIS/device/: system_n32h47x_48x.c
  group FWLB
    ../../firmware/n32h47x_48x_std_periph_driver/src/: misc.c n32h47x_48x_adc.c n32h47x_48x_comp.c n32h47x_48x_cordic.c n32h47x_48x_crc.c n32h47x_48x_dac.c n32h47x_48x_dbg.c n32h47x_48x_dma.c n32h47x_48x_dvp.c n32h47x_48x_eth.c n32h47x_48x_exti.c n32h47x_48x_fdcan.c n32h47x_48x_femc.c n32h47x_48x_flash.c n32h47x_48x_fmac.c n32h47x_48x_gpio.c n32h47x_48x_i2c.c n32h47x_48x_iwdg.c n32h47x_48x_lptim.c n32h47x_48x_pga.c n32h47x_48x_pwr.c n32h47x_48x_rcc.c n32h47x_48x_rtc.c n32h47x_48x_sdio.c n32h47x_48x_shrtim.c n32h47x_48x_spi.c n32h47x_48x_tim.c n32h47x_48x_usart.c n32h47x_48x_vrefbuf.c n32h47x_48x_wwdg.c n32h47x_48x_xspi.c
  group CherryUSB
    ../../CherryUSB/core/: usbd_core.c
    ../../CherryUSB/class/cdc/: usbd_cdc_acm.c
    ../../CherryUSB/class/hid/: usbd_hid.c
    ../../CherryUSB/class/msc/: usbd_msc.c
    ../../CherryUSB/class/video/: usbd_video.c
    ../../CherryUSB/class/audio/: usbd_audio.c
    ../../CherryUSB/port/dwc2/: usb_glue_nation.c usb_dc_dwc2.c
  group User
    ../USER/: log.c main.c n32h47x_48x_it.c print_remap.c systick.c cdc_acm_msc_template.c
  group BSP
    ../BSP/: bsp_config.c bsp_spi_flash.c
target n32h48x_device (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H487ZE Nationstech
  pack: Nationstech.N32H48x_DFP.0.9.0
  cpu: as above
  output: USBHS_CDC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32H487, USE_STDPERIPH_DRIVER
  c include: ..\USBD;..\USER;..\BSP;..\..\firmware\CMSIS\core;..\..\firmware\CMSIS\device;..\..\firmware\n32h47x_48x_std_periph_driver\inc;..\..\CherryUSB\core;..\..\CherryUSB\common;..\..\CherryUSB\class\cdc;..\..\CherryUSB\class\hid;..\..\CherryUSB\class\msc;..\..\CherryUSB\class\hub;..\..\CherryUSB\class\video;..\..\CherryUSB\class\audio
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
